# Keil uVision project C51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: C51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: C51.c c51.h
  group driver
    ./driver/: eeprom52.h key.H LCD1602.H key.c uart.c uart.h HAL_INIT.h HAL_INIT.c LCD1602.c queue.c queue.h
  group app
    ./app/: display.c display.h time.c time.h wendu.c wendu.h key_task.c key_task.h
